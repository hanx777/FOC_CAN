# Keil uVision project demo_CANopenMOTOR.uvprojx, settings and files
target demo_CANopenMOTOR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: demo_CANopenMOTOR +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Hardware;../SguanFOC;..\CANopen\core\inc;..\CANopen\hw_interface;..\CANopen
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c fdcan.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_fdcan.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Hardware
    ../Hardware/: HW_Timer.c HW_Timer.h MT6701.c MT6701.h HW_Key.c HW_Key.h
  group SguanFOC
    ../SguanFOC/: Sguan_Cogging.c Sguan_Cogging.h Sguan_Config.h Sguan_DOB.c Sguan_DOB.h Sguan_Feedforward.c Sguan_Feedforward.h Sguan_Filter.c Sguan_Filter.h Sguan_Hall.c Sguan_Hall.h Sguan_HFI.c Sguan_HFI.h Sguan_Identify.c Sguan_Identify.h Sguan_IQmath.c Sguan_IQmath.h Sguan_Ladrc.c Sguan_Ladrc.h Sguan_LTD.c Sguan_LTD.h Sguan_math.c Sguan_math.h Sguan_MotorStatus.c Sguan_MotorStatus.h Sguan_NLFO.c Sguan_NLFO.h Sguan_NSD.c Sguan_NSD.h Sguan_Optimize.c Sguan_Optimize.h Sguan_PID.c Sguan_PID.h Sguan_PLL.c Sguan_PLL.h Sguan_printf.c Sguan_printf.h Sguan_SMC.c Sguan_SMC.h Sguan_SMO.c Sguan_SMO.h Sguan_SPWM.c Sguan_SPWM.h Sguan_STA.c Sguan_STA.h Sguan_SVPWM.c Sguan_SVPWM.h SguanFOC.c SguanFOC.h UserData_Config.h UserData_Function.h UserData_Motor.h UserData_Parameter.h UserData_Status.h UserData_UserControl.h
  group CANopen/Port
    ../CANopen/hw_interface/: can_driver.c timer_driver.c
    ../CANopen/: cia402appl.c objDict_SingleAxis.c
  group CANopen/Stack
    ../CANopen/core/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
software components: CMSIS:CORE 6.1.0
